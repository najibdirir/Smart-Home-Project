# IAR project smart_home.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM3X8E Microchip ATSAM3X8E
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Microchip\sam3x8\flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cstartup.s data_structure_linkedList.c data_structure_linkedList.h date_and_time.c date_and_time.h display.c display.h exceptions.c interrupt_handlers.c interrupt_handlers.h keypad.c keypad.h light_sensor.c light_sensor.h main.c make_temperature_data.c make_temperature_data.h One_for_all_header.h print_functions.c print_functions.h servo.c servo.h shader.c shader.h startup_sam3x.c system_sam3x.c temperature_sensor.c temperature_sensor.h user_interface.c user_interface.h
